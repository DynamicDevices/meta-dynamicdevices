# Fix imx-vpu-hantro build failure
TOOLCHAIN:pn-imx-vpu-hantro-daemon = "gcc"
