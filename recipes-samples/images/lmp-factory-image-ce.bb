SUMMARY = "LMP factory image with CE testing support"

require recipes-samples/images/lmp-factory-image.bb
require recipes-samples/images/lmp-feature-ce-testing.inc
