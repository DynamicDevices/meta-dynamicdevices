#SYSTEMD_AUTO_ENABLE:${PN}-lite:imx8mm-jaguar-sentai = "mask"
