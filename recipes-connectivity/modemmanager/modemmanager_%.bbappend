FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Add this in when we need to debug the modem manager
#SRC_URI:append = "file://enable-debug.patch"
